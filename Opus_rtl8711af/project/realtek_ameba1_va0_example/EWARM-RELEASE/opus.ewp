# IAR project opus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A
  ICCARM.CCIncludePath2: ..\..\..\external\opus\include; ..\..\..\external\opus\celt; ..\..\..\external\opus\celt\arm; ..\..\..\external\opus\silk; ..\..\..\external\opus\silk\fixed; ..\..\..\external\opus\silk\float; ..\..\..\external\opus\NE_10; ..\inc; ..\..\..\component\soc\realtek\8711b\cmsis; ..\..\..\component\soc\realtek\8711b\misc\bsp; ..\..\..\component\common\drivers; ..\..\..\component\common\application; ..\..\..\opus\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\os\os_dep\include; C:\Users\PCCUBE\Desktop\Opus_rtl8711af\component\os\freertos\freertos_v8.1.2
  OBJCOPY.OOCOutputFile: opus.srec
  ILINK.IlinkOutputFile: opus.out
  ILINK.IlinkKeepSymbols: bootloader; gImage2EntryFun0; RAM_IMG2_VALID_PATTEN
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group celt
    ../../../external/opus/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c opus_custom_demo.c pitch.c quant_bands.c rate.c vq.c
  group celt/arm
    ../../../external/opus/celt/arm/: arm_celt_map.c armcpu.c celt_fft_ne10.c celt_mdct_ne10.c celt_neon_intr.c pitch_neon_intr.c
  group celt/dump_modes
    ../../../external/opus/celt/dump_modes/: dump_modes.c dump_modes_arm_ne10.c
  group celt/tests
    ../../../external/opus/celt/tests/: test_unit_cwrs32.c test_unit_dft.c test_unit_entropy.c test_unit_laplace.c test_unit_mathops.c test_unit_mdct.c test_unit_rotation.c test_unit_types.c
  group m4
    ../../../external/opus/m4/: as-gcc-inline-assembly.m4 ax_add_fortify_source.m4 opus-intrinsics.m4
  group silk
    ../../../external/opus/silk/: A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c CNG.c code_signs.c control_audio_bandwidth.c control_codec.c control_SNR.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF2A.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NSQ.c NSQ_del_dec.c pitch_est_tables.c PLC.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c resampler_private_IIR_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c VAD.c VQ_WMat_EC.c
  group silk/arm
    ../../../external/opus/silk/arm/: arm_silk_map.c biquad_alt_neon_intr.c LPC_inv_pred_gain_neon_intr.c NSQ_del_dec_neon_intr.c NSQ_neon.c
  group silk/fixed
    ../../../external/opus/silk/fixed/: apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
  group silk/fixed/arm
    ../../../external/opus/silk/fixed/arm/: warped_autocorrelation_FIX_neon_intr.c
  group silk/float
    ../../../external/opus/silk/float/: apply_sine_window_FLP.c autocorrelation_FLP.c burg_modified_FLP.c bwexpander_FLP.c corrMatrix_FLP.c encode_frame_FLP.c energy_FLP.c find_LPC_FLP.c find_LTP_FLP.c find_pitch_lags_FLP.c find_pred_coefs_FLP.c inner_product_FLP.c k2a_FLP.c LPC_analysis_filter_FLP.c LPC_inv_pred_gain_FLP.c LTP_analysis_filter_FLP.c LTP_scale_ctrl_FLP.c noise_shape_analysis_FLP.c pitch_analysis_core_FLP.c process_gains_FLP.c regularize_correlations_FLP.c residual_energy_FLP.c scale_copy_vector_FLP.c scale_vector_FLP.c schur_FLP.c sort_FLP.c warped_autocorrelation_FLP.c wrappers_FLP.c
  group silk/tests
    ../../../external/opus/silk/tests/: test_unit_LPC_inv_pred_gain.c
  group src
    ../../../external/opus/src/: analysis.c mapping_matrix.c mlp.c mlp_data.c opus.c opus_compare.c opus_decoder.c opus_demo.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c opus_projection_decoder.c opus_projection_encoder.c repacketizer.c repacketizer_demo.c
  group tests
    ../../../external/opus/tests/: test_opus_decode.c test_opus_encode.c
